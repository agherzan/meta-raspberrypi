# SPDX-FileCopyrightText: meta-raspberrypi contributors
#
# SPDX-License-Identifier: MIT

RDEPENDS:packagegroup-meta-oe-kernel:remove:rpi = "bpftool"
