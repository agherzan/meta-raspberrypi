# Copyright (C) 2017 O.S. Systems Software LTDA.

PACKAGECONFIG_GL_rpi   = "gles2 eglfs"
