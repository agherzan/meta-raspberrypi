FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
PRINC = "1"
