RDEPENDS_${PN}_rpi += "rpi-u-boot-scr"
