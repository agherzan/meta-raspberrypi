# SPDX-FileCopyrightText: meta-raspberrypi contributors
#
# SPDX-License-Identifier: MIT

CONFLICTS = "vc-graphics-hardfp"

VCDIR = "opt/vc"
require vc-graphics.inc

PR = "${INCPR}.0"
