# SPDX-FileCopyrightText: Andrei Gherzan <andrei.gherzan@huawei.com>
# SPDX-FileCopyrightText: meta-raspberrypi contributors
#
# SPDX-License-Identifier: MIT

require linux-raspberrypi-v7.inc
require linux-raspberrypi_5.10.bb
