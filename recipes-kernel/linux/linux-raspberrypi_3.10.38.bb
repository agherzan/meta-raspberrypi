require linux-raspberrypi.inc

SRCREV = "1b49b450222df26e4abf7abb6d9302f72b2ed386"
KBRANCH = "rpi-3.10.y"
