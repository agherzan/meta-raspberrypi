require linux-raspberrypi.inc

SRCREV = "377c82aa1d31b37f1096096b0e4c65beb0bc5c49"
KBRANCH = "rpi-3.16.y"
