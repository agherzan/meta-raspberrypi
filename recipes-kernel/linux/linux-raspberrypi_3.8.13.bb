require linux-raspberrypi.inc

SRCREV = "d996a1b91b2bf3dc06f4f4f822a56f4496457aa1"
KBRANCH = "rpi-3.8.y"
