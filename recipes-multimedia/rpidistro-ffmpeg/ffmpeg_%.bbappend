PROVIDES:append = " virtual/ffmpeg"
