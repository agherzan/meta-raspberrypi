PROVIDES = "virtual/vlc"
