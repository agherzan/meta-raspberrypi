RPROVIDES:${PN} += " xxd"
